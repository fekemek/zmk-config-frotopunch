## config/boards/shields/frotopunch/Kconfig.defconfig
```kconfig
if SHIELD_FROTOPUNCH

config ZMK_KEYBOARD_NAME 
    default "frotopunch" 

    endif
```
